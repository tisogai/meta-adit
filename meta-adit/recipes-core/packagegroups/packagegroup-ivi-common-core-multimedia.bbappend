RDEPENDS_${PN} += "\
    audiomanager \
    "
